# Keil uVision project F429ZI_Reg.uvprojx, settings and files
target F429ZI_Reg (6230000::V6.23::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F429ZI_Reg
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver
  asm include: .\Startup
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Src
    ./Src/: main.c
  group Driver
    ./Driver/: RCC.c RCC.h
  group Startup
    ./Startup/: startup_stm32f429xx.s
software components: CMSIS:CORE 6.1.1
